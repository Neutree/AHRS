# Keil uVision project deno.uvprojx, settings and files
target AHRS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: deno
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\lib\HAL_OffChip\inc;..\..\lib\HAL_OnChip\inc;..\..\lib\Math\inc;..\..\system;..\..\App
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group OnChip
    ../../lib/HAL_OnChip/src/: USART.cpp TaskManager.cpp GPIO.cpp I2C.cpp
  group OffChip
    ../../lib/HAL_OffChip/src/: LED.cpp mpu6050.cpp
  group system
    ../../system/: main.cpp Interrupt.cpp
  group App
    ../../App/: App.cpp
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
