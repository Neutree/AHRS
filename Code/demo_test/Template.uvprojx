# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\libraries\OffChip\AHRS;.\libraries\OffChip\Gimbal;.\libraries\OffChip\InertialSensor;.\libraries\OffChip\Motor;.\libraries\OnChip\ADC;.\libraries\OnChip\IIC;.\libraries\OnChip\InputCapture;.\libraries\OnChip\PWM;.\libraries\OnChip\SerialPort;.\libraries\OnChip\Timer;.\libraries\ToolBox\Buffer;.\libraries\ToolBox\Math;.\libraries\OffChip\Ultrasonic;.\libraries\OffChip\Remoter;.\libraries\System\Interrupt;.\libraries\System;.\libraries\System\TaskManager;.\libraries\OffChip\Compass;.\libraries\OffChip\Barometer;.\libraries\OffChip;.\libraries\OffChip\GPS;.\libraries\OnChip
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group OnChip
    ./libraries/OnChip/ADC/: ADC.cpp
    ./libraries/OnChip/PWM/: PWM.cpp
    ./libraries/OnChip/SerialPort/: USART.cpp
    ./libraries/OnChip/Timer/: Timer.cpp
    ./libraries/OnChip/InputCapture/: InputCapture_TIM.cpp InputCapture_EXIT.cpp
    ./libraries/OnChip/IIC/: I2C.cpp
    ./libraries/OnChip/: GPIO.cpp
  group OffChip
    ./libraries/OffChip/Gimbal/: Gimbal.cpp
    ./libraries/OffChip/InertialSensor/: MPU6050.cpp
    ./libraries/OffChip/Motor/: StepMotor.cpp
    ./libraries/OffChip/Ultrasonic/: Ultrasonic.cpp
    ./libraries/OffChip/Remoter/: Remoter_PWM_TIM.cpp Remoter_PWM_EXIT.cpp
    ./libraries/OffChip/Barometer/: MS561101.cpp
    ./libraries/OffChip/Compass/: HMC5883.cpp
    ./libraries/OffChip/AHRS/: AHRS_DCM.cpp
    ./libraries/OffChip/GPS/: GPS.cpp
    ./libraries/OffChip/: LED.cpp
  group ToolBox
    ./libraries/ToolBox/Math/: Quaternion.cpp Vector3.h Matrix3.h
  group App
    ./: main.cpp
  group System
    ./libraries/System/TaskManager/: TaskManager.cpp
    ./libraries/System/: Configuration.h
    ./libraries/System/Interrupt/: Interrupt.cpp
software components: CMSIS:CORE 4.1.0, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
